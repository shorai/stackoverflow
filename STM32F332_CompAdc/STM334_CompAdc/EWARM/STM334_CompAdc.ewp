# IAR project STM334_CompAdc.ewp, settings and files
configuration STM334_CompAdc Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32F334x8 ST STM32F334x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F334x8
  ICCARM.CCIncludePath2: ..\Inc; ..\Drivers\STM32F3xx_HAL_Driver\Inc; ..\Drivers\CMSIS\Include; ..\Drivers\CMSIS\Device\ST\STM32F3xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: STM334_CompAdc Configuration.out
  ILINK.IlinkIcfFile: stm32f334x8_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group 
    ./: 
  group Drivers
    ./: 
  group Drivers/CMSIS
    ./: 
    ../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ./: 
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_gpio.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_adc.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_comp.c stm32f3xx_hal_flash.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_dac.c stm32f3xx_hal_gpio.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_adc.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_comp.c stm32f3xx_hal_flash.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_dac.c
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Application
    ./: 
  group Application/User
    ./: 
    ../Src/: main.c stm32f3xx_hal_msp.c stm32f3xx_it.c main.c stm32f3xx_hal_msp.c stm32f3xx_it.c
  group Application/EWARM
    ./: 
    ../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/iar/: startup_stm32f334x8.s startup_stm32f334x8.s
  group Application/
    ./: 
  group Application/
    ./: 
